Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-02-02T13:54:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 02 13:54:37 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{8C5BD99D-006E-47B3-B07C-5A8A073A2766}\ifc * Database version: 5507 * Database creation date: Fri Feb 02 13:54:37 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Feb 02 13:54:37 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 02 13:54:37 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVWW28UCSA, HC_Heat Pump_MEPcontent_Hisense_AVWW28-54UCSA_INT-EN:AVWW28UCSA:1299519
In: V00
Type - Material: Color RGB 000-204-204, Color RGB 168-128-048, Color RGB 255-255-255
Type - Dimensions - Depth: 370 mm; Drain Diameter: 18 mm; Height: 800 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 9.5 mm; Water Inlet Diameter: 25 mm; Water Outlet Diameter: 25 mm; Width: 800 mm
Type - Electrical - ELB Nominal Current: 25 A; Hertz: 50 Hz; Maximum Running Current: 16.9 A; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Heat pump outdoor unit; Article Type: AVWW28UCSA; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 3.0; ETIM Article Class: EC001213; Family Version: 11.12; Manufacturer: Hisense; Manufacturer Art. No.: AVWW28UCSA; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVWW28UCSA; OmniClass Number: 23.75.10.24.21.24; OmniClass Title: Liquid Coolers and Evaporative Condensers; Product Line: Hi-Flexi W Series; Revit Version: 2016; Type Name: AVWW28UCSA; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Green: Color RGB 000-204-204; White: Color RGB 255-255-255; Yellow: Color RGB 168-128-048
Type - Mechanical - Loads - Cooling Capacity (kW): 8; Cooling EER (kW/kW): 4.2; Cooling Power Input (kW): 1.9; Heating Capacity (kW): 9; Heating COP (kW/kW): 5; Heating Power Input (kW): 1.8; Sound Pressure Level (dB(A)): 49; Unit Weight (kg): 70
Type - Other - Category: Mechanical Equipment; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVWW28-54UCSA_INT-EN; Use Nominal Diameter: yes
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 5.54905 m2; Volume: 1.90305 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Undefined,Power,Domestic Hot Water,Domestic Cold Water,Sanitary; Water Inlet Flow: 0 m3/s; Water Outlet Flow: 0 m3/s
Other - Back Clearance Safe: 300 mm; Family: HC_Heat Pump_MEPcontent_Hisense_AVWW28-54UCSA_INT-EN: AVWW28UCSA; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVWW28-54UCSA_INT-EN: AVWW28UCSA; Front Clearance Safe: 500 mm; Left Clearance Safe: 300 mm; Right Clearance Safe: 200 mm; Top Clearance Safe: 300 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVWW28-54UCSA_INT-EN: AVWW28UCSA; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVWW28-54UCSA_INT-EN: AVWW28UCSA
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 300 mm; Front Clearance: 500 mm; Left Clearance: 300 mm; Right Clearance: 200 mm; Service Space: no; Top Clearance: 300 mm
